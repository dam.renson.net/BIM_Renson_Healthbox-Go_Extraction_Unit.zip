Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: 0001
Time: 2024-05-14T09:46:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 14 09:46:16 2024 * Host: RENSON-PC64rjMe * Database: C:\Users\naniw\AppData\Local\Temp\fee6e291-ec62-47fd-af19-bf683f76642b\744ca297-3d59-4fc4-b500-3c63466978bf\ifc * Database version: 5507 * Database creation date: Tue May 14 09:46:12 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue May 14 09:46:12 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 14 09:46:12 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 0

# IfcAirTerminalBox: Healthbox Go, Renson_Healthbox Go_Extraction_Unit:Healthbox Go:458799
Type - Material: Color RGB 043-043-044
Type - Pset_AirTerminalBoxTypeCommon - Reference: Healthbox Go
Type - Pset_EnvironmentalImpactIndicators - Reference: Healthbox Go
Type - Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_AirTerminalBoxTypeCommon - sets with these values: 2

# IfcDuctFitting: 125 (7)
Type - PredefinedType: TRANSITION; Classification: ﻿﻿ ​ ​ ​ ﻿ ​ ​ ﻿ ​ ​ ﻿ ​﻿ ​ ​ ﻿ ﻿﻿ (Uniformat); Material: Color RGB 043-043-044
Type - Pset_DuctFittingTypeCommon - Reference: 125
Type - Pset_EnvironmentalImpactIndicators - Reference: 125
Type - Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_DuctFittingTypeCommon - sets with these values: 2
Name (Renson_Healthbox Go_Round_Adapter 125:125:...)
458800
458801
458802
458803
458804
458805
458806

# IfcDuctFitting: 125-150, Renson_Healthbox Go_Round_Exhaust Adapter 125-150:125-150:490957
Type - PredefinedType: TRANSITION; Classification: ﻿﻿ ​ ​ ​ ﻿ ​ ​ ﻿ ​ ​ ﻿ ​﻿ ​ ​ ﻿ ﻿﻿ (Uniformat); Material: Color RGB 043-043-044
Type - Pset_DuctFittingTypeCommon - Reference: 125-150
Type - Pset_EnvironmentalImpactIndicators - Reference: 125-150
Type - Pset_ManufacturerTypeInformation - Manufacturer: Renson
Pset_DuctFittingTypeCommon - sets with these values: 2
